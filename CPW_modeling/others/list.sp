RG010      		a          		p          		'1/G0'
C010       		a          		p          		'C0'
RG011      		a          		np011      		'1/G1'
C011       		np011      		p          		'C1'
RG012      		a          		np012      		'1/G2'
C012       		np012      		p          		'C2'
RG013      		a          		np013      		'1/G3'
C013       		np013      		p          		'C3'
R010       		a          		ns011      		'RO'
R010       		ns011      		ns012      		'LO'
R011       		ns012      		ns013      		'R1'
L011       		ns012      		ns013      		'L1'
R012       		ns013      		ns014      		'R2'
L012       		ns013      		ns014      		'L2'
R013       		ns014      		b          		'R3'
L013       		ns014      		b          		'L3'
RG020      		b          		p          		'1/G0'
C020       		b          		p          		'C0'
RG021      		b          		np021      		'1/G1'
C021       		np021      		p          		'C1'
RG022      		b          		np022      		'1/G2'
C022       		np022      		p          		'C2'
RG023      		b          		np023      		'1/G3'
C023       		np023      		p          		'C3'
