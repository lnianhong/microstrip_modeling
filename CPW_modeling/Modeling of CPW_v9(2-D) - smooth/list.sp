RG010      		a          		p          		'2*RG0'
C010       		a          		p          		'0.5*C0'
RG011      		a          		np011      		'2*RG1'
C011       		np011      		p          		'0.5*C1'
RG012      		a          		np012      		'2*RG2'
C012       		np012      		p          		'0.5*C2'
RG013      		a          		np013      		'2*RG3'
C013       		np013      		p          		'0.5*C3'
R010       		a          		ns011      		'R0'
L010       		ns011      		ns012      		'L0'
R011       		ns012      		ns013      		'R1'
L011       		ns012      		ns013      		'L1'
R012       		ns013      		ns014      		'R2'
L012       		ns013      		ns014      		'L2'
R013       		ns014      		ns015      		'R3'
L013       		ns014      		ns015      		'L3'
RG020      		ns015      		p          		'RG0'
C020       		ns015      		p          		'C0'
RG021      		ns015      		np021      		'RG1'
C021       		np021      		p          		'C1'
RG022      		ns015      		np022      		'RG2'
C022       		np022      		p          		'C2'
RG023      		ns015      		np023      		'RG3'
C023       		np023      		p          		'C3'
R020       		ns015      		ns021      		'R0'
L020       		ns021      		ns022      		'L0'
R021       		ns022      		ns023      		'R1'
L021       		ns022      		ns023      		'L1'
R022       		ns023      		ns024      		'R2'
L022       		ns023      		ns024      		'L2'
R023       		ns024      		ns025      		'R3'
L023       		ns024      		ns025      		'L3'
RG030      		ns025      		p          		'RG0'
C030       		ns025      		p          		'C0'
RG031      		ns025      		np031      		'RG1'
C031       		np031      		p          		'C1'
RG032      		ns025      		np032      		'RG2'
C032       		np032      		p          		'C2'
RG033      		ns025      		np033      		'RG3'
C033       		np033      		p          		'C3'
R030       		ns025      		ns031      		'R0'
L030       		ns031      		ns032      		'L0'
R031       		ns032      		ns033      		'R1'
L031       		ns032      		ns033      		'L1'
R032       		ns033      		ns034      		'R2'
L032       		ns033      		ns034      		'L2'
R033       		ns034      		ns035      		'R3'
L033       		ns034      		ns035      		'L3'
RG040      		ns035      		p          		'RG0'
C040       		ns035      		p          		'C0'
RG041      		ns035      		np041      		'RG1'
C041       		np041      		p          		'C1'
RG042      		ns035      		np042      		'RG2'
C042       		np042      		p          		'C2'
RG043      		ns035      		np043      		'RG3'
C043       		np043      		p          		'C3'
R040       		ns035      		ns041      		'R0'
L040       		ns041      		ns042      		'L0'
R041       		ns042      		ns043      		'R1'
L041       		ns042      		ns043      		'L1'
R042       		ns043      		ns044      		'R2'
L042       		ns043      		ns044      		'L2'
R043       		ns044      		ns045      		'R3'
L043       		ns044      		ns045      		'L3'
RG050      		ns045      		p          		'RG0'
C050       		ns045      		p          		'C0'
RG051      		ns045      		np051      		'RG1'
C051       		np051      		p          		'C1'
RG052      		ns045      		np052      		'RG2'
C052       		np052      		p          		'C2'
RG053      		ns045      		np053      		'RG3'
C053       		np053      		p          		'C3'
R050       		ns045      		ns051      		'R0'
L050       		ns051      		ns052      		'L0'
R051       		ns052      		ns053      		'R1'
L051       		ns052      		ns053      		'L1'
R052       		ns053      		ns054      		'R2'
L052       		ns053      		ns054      		'L2'
R053       		ns054      		ns055      		'R3'
L053       		ns054      		ns055      		'L3'
RG060      		ns055      		p          		'RG0'
C060       		ns055      		p          		'C0'
RG061      		ns055      		np061      		'RG1'
C061       		np061      		p          		'C1'
RG062      		ns055      		np062      		'RG2'
C062       		np062      		p          		'C2'
RG063      		ns055      		np063      		'RG3'
C063       		np063      		p          		'C3'
R060       		ns055      		ns061      		'R0'
L060       		ns061      		ns062      		'L0'
R061       		ns062      		ns063      		'R1'
L061       		ns062      		ns063      		'L1'
R062       		ns063      		ns064      		'R2'
L062       		ns063      		ns064      		'L2'
R063       		ns064      		b          		'R3'
L063       		ns064      		b          		'L3'
RG070      		b          		p          		'2*RG0'
C070       		b          		p          		'0.5*C0'
RG071      		b          		np071      		'2*RG1'
C071       		np071      		p          		'0.5*C1'
RG072      		b          		np072      		'2*RG2'
C072       		np072      		p          		'0.5*C2'
RG073      		b          		np073      		'2*RG3'
C073       		np073      		p          		'0.5*C3'
